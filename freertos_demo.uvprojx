# Keil uVision project freertos_demo.uvprojx, settings and files
target freertos_demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freertos_demo
  AfterMake: fromelf --bin --output .\rvmdk\freertos_demo.bin .\rvmdk\freertos_demo.axf
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: .;..;..\..\..\..;..\..\..\..\third_party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\third_party\FreeRTOS;..\..\..\..\third_party\FreeRTOS\Source\include;..\..\..\..\third_party
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: freertos_demo.sct
  link misc: --entry Reset_Handler
  group Source
    ../drivers/: buttons.c rgb.c
    ./: freertos_demo.c startup_rvmdk.S tarefa_servo.c tarefa_switch.c
    ../../../../third_party/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../../third_party/FreeRTOS/Source/: list.c queue.c tasks.c
    ../../../../third_party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../utils/: uartstdio.c ustdlib.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
software components: CMSIS:CORE 5.1.2
